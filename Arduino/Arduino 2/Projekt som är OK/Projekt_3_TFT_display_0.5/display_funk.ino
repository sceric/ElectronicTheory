

void frame() {
  myGLCD.setColor(255, 0, 0);
  myGLCD.fillRect(0, 0, 479, 13);
  myGLCD.setColor(64, 64, 64);
  myGLCD.fillRect(0, 306, 479, 319);
  myGLCD.setColor(255, 255, 255);
  myGLCD.setBackColor(255, 0, 0);
  myGLCD.print("* Universal Display *", CENTER, 3);
  myGLCD.setBackColor(64, 64, 64);
  myGLCD.setColor(255, 255, 0);
  myGLCD.print("Sefik Ceric, Baxter", CENTER, 307);

  myGLCD.setColor(0, 0, 255);
  myGLCD.drawRect(0, 14, 479, 305);

}
//______________________________________________________________

void text_name() {
  myGLCD.setFont(FreeSerifBoldItalic24pt7b);
  myGLCD.setBackColor(0, 0, 0);
  myGLCD.setTextSize(1);
  myGLCD.print("Sefik Ceric", 130, 120);
  myGLCD.setFont(SmallFont);
}

void text_name_Baxter(int with, int hight, char *text) {
  myGLCD.setFont(FreeSerifBoldItalic24pt7b);
  myGLCD.setBackColor(0, 0, 0);
  myGLCD.setTextSize(1);
  myGLCD.print(text, with, hight);
  myGLCD.setFont(SmallFont);
}

void text_name_Tel(int with, int hight, char *text) {
  myGLCD.setFont(BigFont);
  myGLCD.setBackColor(0, 0, 0);
  myGLCD.setTextSize(1);
  myGLCD.print(text, with, hight);
  myGLCD.setFont(SmallFont);
}

void button_next(){

  myGLCD.setColor (255, 0, 0);
  myGLCD.drawRoundRect (400, 270, 470, 295); //xstart, ystart,xslut,yslut på line
  myGLCD.setColor (27, 254, 3);
  myGLCD.fillRoundRect(402, 272, 468, 293);
  myGLCD.setBackColor(27, 254, 3);
  myGLCD.setFont(BigFont);
  myGLCD.setTextSize(0);
  myGLCD.setColor(0, 0, 255);
  myGLCD.print("Next", 405, 275);
  myGLCD.setFont(SmallFont);
  
  myGLCD.setTextSize(1);
  
}


void lines_patern() {


  myGLCD.setColor(0, 0, 255);
  text_name_Baxter(177, 60, "Baxter");
  myGLCD.setColor (239, 254, 3);
  text_name_Tel(177, 220, "Tel:1174");
  myGLCD.setColor (239, 254, 3);
  myGLCD.drawRoundRect (167, 210, 317, 244); //xstart, ystart,xslut,yslut på line
  myGLCD.setColor (255, 0, 0);
  text_name();

 
   myGLCD.setColor (255, 0, 0);
  // text_name(int with, int hight, char *text)
  for (int i = 15; i < 304; i += 5)
  {
    myGLCD.drawLine(1, i, (i * 1.6) - 10, 304);


  }
  myGLCD.setColor (255, 0, 0);
  for (int i = 304; i > 15; i -= 5)
  {
    myGLCD.drawLine(478, i, (i * 1.6) - 11, 15);

  }
  myGLCD.setColor (0, 255, 255);
  text_name();
  for (int i = 304; i > 15; i -= 5)
  {
    myGLCD.drawLine(1, i, 491 - (i * 1.6), 15);

  }
  myGLCD.setColor (0, 255, 255);
  for (int i = 15; i < 304; i += 5)
  {
    myGLCD.drawLine(478, i, 490 - (i * 1.6), 304);

  }

 button_next();
}

//_________________________________________________________________


