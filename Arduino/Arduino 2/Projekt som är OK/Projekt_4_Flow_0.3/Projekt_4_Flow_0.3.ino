//#include <TouchScreen.h>
#include <Adafruit_GFX.h>
#include <UTFTGLUE.h>
           
UTFTGLUE myGLCD(0x9488,A2,A1,A3,A4,A0);
long int i=-20;
long int k=0;
double p=1.0000;
long int s=-20;
long int f=-20;
int x=420;


void setup()
{
  //randomSeed(analogRead(0));
  
// Setup the LCD
  myGLCD.InitLCD();
  frame();

}
void loop()
{

   if(i==85){
     i=-20;
   }

   if(k==101){
     k=0;
   }

    if(p==9.9999){
      k=0.0000;
   }

    if(s==100){
      s=-20;
   }

    if(f==100){
      f=-20;
   }
 
   clock_time();
   temperature(i);
   humidity(k);
   pressure(p);
   rain(s);
   flow_status(f);
   
   i=i+1;
   k=k+1;
   p=p+0.0001;
   s=s+10;
   
   

}

