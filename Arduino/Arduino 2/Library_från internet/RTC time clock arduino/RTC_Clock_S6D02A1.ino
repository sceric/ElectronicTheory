
#include <DS3232RTC.h>    //http://github.com/JChristensen/DS3232RTC
#include <Time.h>         //http://www.arduino.cc/playground/Code/Time  
#include <Wire.h>         //http://arduino.cc/en/Reference/Wire (included with Arduino IDE)

#include <TFT_S6D02A1.h> // Graphics and font library for S6D02A1 driver chip
#include <SPI.h>

TFT_S6D02A1 tft = TFT_S6D02A1();  // Invoke library, pins defined in User_Setup.h

#define S6D02A1_GREY 0xBDF7

float sx = 0, sy = 1, mx = 1, my = 0, hx = -1, hy = 0;    // Saved H, M, S x & y multipliers
float sdeg = 0, mdeg = 0, hdeg = 0;
uint16_t osx = 64, osy = 64, omx = 64, omy = 64, ohx = 64, ohy = 64; // Saved H, M, S x & y coords
uint16_t x0 = 0, x1 = 0, y0 = 0, y1 = 0;

uint8_t hh = 0, mm = 0, ss = 0; // To store time
uint8_t oldSecs = 0;

boolean initial = 1;

void setup(void) {

  Serial.begin(9600);

  setSyncProvider(RTC.get);   // the function to get the time from the RTC
  if (timeStatus() != timeSet)
    Serial.println("Unable to sync with the RTC");
  else
    Serial.println("RTC has set the system time");

  tft.init();
  tft.setRotation(0);
  tft.fillScreen(S6D02A1_GREY);
  tft.setTextColor(S6D02A1_GREEN, S6D02A1_GREY);  // Adding a black background colour erases previous text automatically

  // Draw clock face
  tft.fillCircle(64, 64, 61, S6D02A1_BLUE);
  tft.fillCircle(64, 64, 57, S6D02A1_BLACK);

  // Draw 12 lines
  for (int i = 0; i < 360; i += 30) {
    sx = cos((i - 90) * 0.0174532925);
    sy = sin((i - 90) * 0.0174532925);
    x0 = sx * 57 + 64;
    y0 = sy * 57 + 64;
    x1 = sx * 50 + 64;
    y1 = sy * 50 + 64;

    tft.drawLine(x0, y0, x1, y1, S6D02A1_BLUE);
  }

  // Draw 60 dots
  for (int i = 0; i < 360; i += 6) {
    sx = cos((i - 90) * 0.0174532925);
    sy = sin((i - 90) * 0.0174532925);
    x0 = sx * 53 + 64;
    y0 = sy * 53 + 64;

    tft.drawPixel(x0, y0, S6D02A1_BLUE);
    if (i == 0 || i == 180) tft.fillCircle(x0, y0, 1, S6D02A1_CYAN);
    if (i == 0 || i == 180) tft.fillCircle(x0 + 1, y0, 1, S6D02A1_CYAN);
    if (i == 90 || i == 270) tft.fillCircle(x0, y0, 1, S6D02A1_CYAN);
    if (i == 90 || i == 270) tft.fillCircle(x0 + 1, y0, 1, S6D02A1_CYAN);
  }

  tft.fillCircle(65, 65, 3, S6D02A1_RED);

  // Draw text at position 64,125 using fonts 4
  // Only font numbers 2,4,6,7 are valid. Font 6 only contains characters [space] 0 1 2 3 4 5 6 7 8 9 : . a p m
  // Font 7 is a 7 segment font and only contains characters [space] 0 1 2 3 4 5 6 7 8 9 : .
  tft.drawCentreString("Time flies", 64, 130, 4);
}

void loop() {
  byte ss = second();
  if (ss != oldSecs) {
    oldSecs = ss;
    mm = minute();
    hh = hour();

    // Pre-compute hand degrees, x & y coords for a fast screen update
    sdeg = ss * 6;                // 0-59 -> 0-354
    mdeg = mm * 6 + sdeg * 0.01666667; // 0-59 -> 0-360 - includes seconds
    hdeg = hh * 30 + mdeg * 0.0833333; // 0-11 -> 0-360 - includes minutes and seconds
    hx = cos((hdeg - 90) * 0.0174532925);
    hy = sin((hdeg - 90) * 0.0174532925);
    mx = cos((mdeg - 90) * 0.0174532925);
    my = sin((mdeg - 90) * 0.0174532925);
    sx = cos((sdeg - 90) * 0.0174532925);
    sy = sin((sdeg - 90) * 0.0174532925);

    if (ss == 0 || initial) {
      initial = 0;
      // Erase hour and minute hand positions every minute
      tft.drawLine(ohx, ohy, 65, 65, S6D02A1_BLACK);
      ohx = hx * 33 + 65;
      ohy = hy * 33 + 65;
      tft.drawLine(omx, omy, 65, 65, S6D02A1_BLACK);
      omx = mx * 44 + 65;
      omy = my * 44 + 65;
    }

    // Redraw new hand positions, hour and minute hands not erased here to avoid flicker
    tft.drawLine(osx, osy, 65, 65, S6D02A1_BLACK);
    tft.drawLine(ohx, ohy, 65, 65, S6D02A1_WHITE);
    tft.drawLine(omx, omy, 65, 65, S6D02A1_WHITE);
    osx = sx * 47 + 65;
    osy = sy * 47 + 65;
    tft.drawLine(osx, osy, 65, 65, S6D02A1_RED);

    tft.fillCircle(65, 65, 3, S6D02A1_RED);
  }
}


